Commit message: Update widowx urdf (reverse axis)

File: configs/urdfs/wx250s.urdf (robot description, URDF)
Before this commit: robot wx250s, 14 links, 13 joints
Joints:
- joint elbow: axis 0 1 0 -> 0 -1 0
- joint wrist_angle: axis 0 1 0 -> 0 -1 0
